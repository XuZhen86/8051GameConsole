# Keil uVision project Lcd12864.uvproj, settings and files
target Target (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Lcd12864 +hex
  c flags: Optimize=11 SizeSpeed=1
  group Main
    ./Sources/Main/: main.c STARTUP.A51 STC15W4K48S4.h
  group Games_Snake
    ./Sources/Games/Snake/: Snake.c Snake.h
  group ADC
    ./Sources/ADC/: ADC.c ADC.h
  group I23LC512
    ./Sources/I23LC512/: I23LC512.c I23LC512.h
  group InterruptRoutine
    ./Sources/InterruptRoutine/: InterruptRoutine.c
  group Joystick
    ./Sources/Joystick/: Joystick.c Joystick.h
  group LCD12864
    ./Sources/LCD12864/: LCD12864.c LCD12864.h LCD12864_ASCII5x8.h LCD12864_ASCII6x8.h
  group Pushbutton
    ./Sources/Pushbutton/: Pushbutton.c Pushbutton.h
  group PWM
    ./Sources/PWM/: PWM.c PWM.h PWM_XSFR.h
  group SPI
    ./Sources/SPI/: SPI.c SPI.h
  group Timer
    ./Sources/Timer/: Timer3.c Timer3.h Timer4.c Timer4.h
  group Universal
    ./Sources/Universal/: Putchar.c SystemClock.c SystemClock.h Universal.c Universal.h
  group Version
    ./Sources/Version/: Version.h Version.c
  group Widgets_ListWidget
    ./Sources/Widgets/ListWidget/: ListWidget.c ListWidget.h
  group IAP
    ./Sources/IAP/: IAP.c IAP.h
